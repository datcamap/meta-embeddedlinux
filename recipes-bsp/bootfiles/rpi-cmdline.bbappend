# ENABLE_UART = "1"
# SERIAL_CONSOLES = "115200;ttyAMA0"
# CMDLINE_SERIAL = "console=ttyAMA0,115200 console=tty1"
CMDLINE:append = " splash vt.global_cursor_default=0 loglevel=0"
