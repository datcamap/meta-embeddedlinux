RPI_EXTRA_CONFIG:append = "\ndtoverlay=disable-bt\n"
